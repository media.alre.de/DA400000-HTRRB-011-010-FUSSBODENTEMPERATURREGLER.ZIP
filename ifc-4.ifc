Properties of the parts of a building model (IFC4)

# File
Description: Fußbodentemperaturregler mit Fernfühler, Aufputz, 10…60 °C, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA400000, Fußbodentemperaturregler mit Fernfühler, Aufputz, 10…60 °C
In: Raum
Description: Zur Temperaturregelung (z. B. Elektroheizung) für Fußboden-, Randzonen-, Badezimmer-, Decken-, Kachelofen-, Marmor- und Wandheizungen bzw. Temperiersysteme. Elektronischer Fußbodentemperaturregler für elektrische Fußbodenheizungen bis zu 3000 W. Mit der unter dem Einstellknopf befindlichen Bereichseinengung kann der Einstellbereich verändert werden (z. B. 10…40 °C). Fernfühler HF-8/4-K2 (4 m) im Lieferumfang enthalten. Bei Fühlerbruch- und -kurzschluss wird die Heizung abgeschaltet.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA400000; ModelLabel: HTRRB-011.010; GlobalTradeItemNumber: 4050528028013; ProductURL: https://alre.de/produkt_DA400000
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.236
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Anschluss: drei-/vieradrig; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Schließer (NO); Messbereich: 10; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 13; Differenzwert: 1; Sensor extern: yes; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA400000.pdf
